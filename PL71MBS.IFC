Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: PL71MBS.IFC
Time: 2023-07-18T06:54:14
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: rivets for name plate gb_GB_OTHERRIVETS_TYPE93 3X4 (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
Name
rivets for name plate gb_GB_OTHERRIVETS_TYPE93 3X4 | PSet_Mass_Property - Mass Measure: 554.249; Area Measure: 1225543 m2; Volume Measure: 549565 m3
11 x rivets for name plate gb_GB_OTHERRIVETS_TYPE93 3X4

# IfcBuildingElementProxy: 筒体-0.9B拉丝.stp<1>[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 筒体-0.9B拉丝.stp<1>[2]
In: Default Storey
PredefinedType: ELEMENT
